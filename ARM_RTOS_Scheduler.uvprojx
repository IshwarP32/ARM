# Keil uVision project ARM_RTOS_Scheduler.uvprojx, settings and files
target ARM_RTOS_Simulator (6210000::V6.21::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(25000000) ELITTLE
  output: ARM_RTOS_Scheduler
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG
  c include: .\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Files
    ./src/: main.c task_manager.c scheduler.c queue_manager.c memory_manager.c timer_manager.c arm_cortex_m.c
    ./: system_ARMCM3.c
  group Header Files
    ./include/: rtos_config.h task_manager.h scheduler.h queue_manager.h memory_manager.h timer_manager.h arm_cortex_m.h
  group Startup
    ./: startup_ARMCM3.s
